# Keil uVision project Code.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Code +hex
  c flags: Optimize=9
  group Source Group 1
    ./: STARTUP.A51 main.c oled.c Timer.c UI.c EEPROM.c
